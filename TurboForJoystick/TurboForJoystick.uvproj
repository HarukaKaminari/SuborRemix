# Keil uVision project TurboForJoystick.uvproj, settings and files
target TurboForJoystick (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: TurboForJoystick +hex
  c flags: Optimize=9 SizeSpeed=1
  group source
    ./: STC15W.h main.c
