# Keil uVision project ReceiverForJoystick.uvproj, settings and files
target ReceiverForJoystick (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: ReceiverForJoystick +hex
  c flags: Optimize=9 SizeSpeed=1
  group source
    ./: STC15W.h main.c
