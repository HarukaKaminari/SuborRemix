# Keil uVision project Mapper3.uvproj, settings and files
target Mapper3 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: Mapper3 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source
    ./: main.c STC15W.h
