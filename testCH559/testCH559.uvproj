# Keil uVision project testCH559.uvproj, settings and files
target test (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: testCH559 +hex
  c flags: Optimize=9 SizeSpeed=1
  group common
    ./: CH559.H typedef.h CH559.c testMain.c
  group devices
    ./: STDIO.c STDIO.h TIMER0.c TIMER0.h EXKM.h KM_CHANGE4V10_48M.LIB KEYBOARD.C KEYBOARD.h SYSTEM.c SYSTEM.h EXPINTERFACE.c EXPINTERFACE.h GPIO.c GPIO.h I2C.c I2C.h SSD1306.c SSD1306.h
